# Keil uVision project LY-STM32.uvproj, settings and files
target LY-STM32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LY-STM32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\System;.\USR;.\UCOSII\CONFIG;.\UCOSII\CORE;.\UCOSII\PORT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group USR
    ./USR/: main.c pbdata.c stm32f10x_it.c led.c usart.c usr_app.c
  group Lib
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c
  group uC-OS-II/PORT
    ./UCOSII/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-OS-II/CORE
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/CONFIG
    ./UCOSII/CONFIG/: includes.h os_cfg.h
