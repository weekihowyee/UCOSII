# Keil uVision project STM3210B-LK1-OS.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL-OS-Probe
  c flags: Optim=2 wLevel=2
  c include: .;..\BSP;..\..\..\..\..\uCOS-II\Ports\arm-cortex-m3\Generic\RealView;..\..\..\..\..\uCOS-II\Source;..\..\..\..\..\CPU\ST\STM32\inc;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\Arm-Cortex-M3\RealView;..\..\..\..\..\uC-LIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
  group APP
    ./: app.c vectors.s STM32F10x.s main.c
  group BSP
    ../BSP/: bsp.c init.s bsp_int.c bsp_periph.c
  group FWL
    ../../../../../CPU/ST/STM32/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_systick.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_lib.c stm32f10x_tim.c stm32f10x_it.c stm32f10x_nvic.c
  group uC-CPU
    ../../../../../uC-CPU/: cpu_def.h
    ../../../../../uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC-OS-II/Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Port
    ../../../../../uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-LIB
    ../../../../../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
